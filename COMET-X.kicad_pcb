# Repository kingovchouffe/COMET-X

## KiCad design COMET-X.kicad_pcb

Parts:
C1, C2, C3: C_0603_1608Metric; not fitted
C4, C5, C6, C7, C8, C18: 22u; C_1206_3216Metric
C9, C10, C26: 10u/50V; CP_Elec_5x5.4
C20: 10n; C_0603_1608Metric
D1: SS34; D_SMA
D2: LED; LED_0805_2012Metric
D8: SS54; D_SMA
H2, H3: MountingHole_3.2mm_M3_Pad_Via
J1: ATX_12V_IN; Molex_Mini-Fit_Jr_5569-08A2_2x04_P4.20mm_Horizontal
L2: 10uH; L_Changjiang_FXL0630
R1: 1k; R_0603_1608Metric
R2: R_0603_1608Metric; not fitted
R15: 10k; R_0603_1608Metric
R16: 5.9k; R_0603_1608Metric
U2: TPS5450ddar; TI_SO-PowerPAD-8_ThermalVias

Connections:
+3V3: C1.1, C4.1, C5.1, C6.1, C7.1, C8.1, L2.2, R1.1, R15.1; also elsewhere on the board
+12V: C9.1, C10.1, C26.1, D1.2 (A), J1.1, J1.2, J1.3; also elsewhere on the board
/VSENS: C1.2, C2.1, C3.1, R15.2, R16.1, U2.4 (VSENSE)
GND: C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C18.2, C26.2, D2.1 (K), D8.2 (A), H2.1, H3.1, J1.4, J1.5, J1.6, J1.7, J1.8, R2.1, R16.2, U2.6 (GND), U2.9 (GNDPAD); also elsewhere on the board
unnamed: C3.2, R2.2
unnamed: D2.2 (A), R1.2
unnamed: C20.1, D8.1 (K), L2.1, U2.8 (PH)
unnamed: C20.2, U2.1 (BOOT)
VBUS: C18.1, D1.1 (K), U2.7 (VIN)

Parts:
J3: G97R24312HR_EP; AMPHENOL_G97R24312HR_mcio_x16; PARTREV AX16
TP1: CLK_P; TestPoint_Pad_D1.0mm
TP2: CLK_N; TestPoint_Pad_D1.0mm
TP3: WAKE; TestPoint_Pad_D1.0mm
TP4: PERST; TestPoint_Pad_D1.0mm
TP5: PRES; TestPoint_Pad_D1.0mm
TP6: 3V3_AUX; TestPoint_Pad_D1.0mm

Connections:
3V3_AUX: J3.B8 (FLEXIO9), TP6.1; also elsewhere on the board
CLK_N: J3.B12 (CLK_N), TP2.1; also elsewhere on the board
CLK_P: J3.B11 (CLK_P), TP1.1; also elsewhere on the board
GND: J3.A1 (GND), J3.A4 (GND), J3.A7 (GND), J3.A10 (GND), J3.A13 (GND), J3.A16 (GND), J3.A19 (GND), J3.A22 (GND), J3.A25 (GND), J3.A28 (GND), J3.A31 (GND), J3.A34 (GND), J3.A37 (GND), J3.A38 (GND), J3.A41 (GND), J3.A44 (GND), J3.A47 (GND), J3.A50 (GND), J3.A53 (GND), J3.A56 (GND), J3.A59 (GND), J3.A62 (GND), J3.B1 (GND), J3.B4 (GND), J3.B7 (GND), J3.B10 (GND), J3.B13 (GND), J3.B16 (GND), J3.B19 (GND), J3.B22 (GND), J3.B25 (GND), J3.B28 (GND), J3.B31 (GND), J3.B34 (GND), J3.B37 (GND), J3.B38 (GND), J3.B41 (GND), J3.B44 (GND), J3.B47 (GND), J3.B50 (GND), J3.B53 (GND), J3.B56 (GND), J3.B59 (GND), J3.B62 (GND), J3.S1 (SHIELD), J3.S2 (SHIELD__1), J3.S3 (SHIELD__2), J3.S4 (SHIELD__3); also elsewhere on the board
PERST: J3.A11 (PERST), TP4.1; also elsewhere on the board
PRES: J3.A12 (PRPE), TP5.1; also elsewhere on the board
RX0_N: J3.A3 (RX0-); also elsewhere on the board
RX0_P: J3.A2 (RX0+); also elsewhere on the board
RX1_N: J3.A6 (RX1-); also elsewhere on the board
RX1_P: J3.A5 (RX1+); also elsewhere on the board
RX2_N: J3.A15 (RX2-); also elsewhere on the board
RX2_P: J3.A14 (RX2+); also elsewhere on the board
RX3_N: J3.A18 (RX3-); also elsewhere on the board
RX3_P: J3.A17 (RX3+); also elsewhere on the board
RX4_N: J3.A21 (RX4-); also elsewhere on the board
RX4_P: J3.A20 (RX4+); also elsewhere on the board
RX5_N: J3.A24 (RX5-); also elsewhere on the board
RX5_P: J3.A23 (RX5+); also elsewhere on the board
RX6_N: J3.A33 (RX6-); also elsewhere on the board
RX6_P: J3.A32 (RX6+); also elsewhere on the board
RX7_N: J3.A36 (RX7-); also elsewhere on the board
RX7_P: J3.A35 (RX7+); also elsewhere on the board
RX8_N: J3.A40 (RX8-); also elsewhere on the board
RX8_P: J3.A39 (RX8+); also elsewhere on the board
RX9_N: J3.A43 (RX9-); also elsewhere on the board
RX9_P: J3.A42 (RX9+); also elsewhere on the board
RX10_N: J3.A46 (RX10-); also elsewhere on the board
RX10_P: J3.A45 (RX10+); also elsewhere on the board
RX11_N: J3.A49 (RX11-); also elsewhere on the board
RX11_P: J3.A48 (RX11+); also elsewhere on the board
RX12_N: J3.A52 (RX12-); also elsewhere on the board
RX12_P: J3.A51 (RX12+); also elsewhere on the board
RX13_N: J3.A55 (RX13-); also elsewhere on the board
RX13_P: J3.A54 (RX13+); also elsewhere on the board
RX14_N: J3.A58 (RX14-); also elsewhere on the board
RX14_P: J3.A57 (RX14+); also elsewhere on the board
RX15_N: J3.A61 (RX15-); also elsewhere on the board
RX15_P: J3.A60 (RX15+); also elsewhere on the board
SCL: J3.A8 (SCL); also elsewhere on the board
SDA: J3.A9 (SDA); also elsewhere on the board
TX0_N: J3.B3 (TX0-); also elsewhere on the board
TX0_P: J3.B2 (TX0+); also elsewhere on the board
TX1_N: J3.B6 (TX1-); also elsewhere on the board
TX1_P: J3.B5 (TX1+); also elsewhere on the board
TX2_N: J3.B15 (TX2-); also elsewhere on the board
TX2_P: J3.B14 (TX2+); also elsewhere on the board
TX3_N: J3.B18 (TX3-); also elsewhere on the board
TX3_P: J3.B17 (TX3+); also elsewhere on the board
TX4_N: J3.B21 (TX4-); also elsewhere on the board
TX4_P: J3.B20 (TX4+); also elsewhere on the board
TX5_N: J3.B24 (TX5-); also elsewhere on the board
TX5_P: J3.B23 (TX5+); also elsewhere on the board
TX6_N: J3.B33 (TX6-); also elsewhere on the board
TX6_P: J3.B32 (TX6+); also elsewhere on the board
TX7_N: J3.B36 (TX7-); also elsewhere on the board
TX7_P: J3.B35 (TX7+); also elsewhere on the board
TX8_N: J3.B40 (TX8-); also elsewhere on the board
TX8_P: J3.B39 (TX8+); also elsewhere on the board
TX9_N: J3.B43 (TX9-); also elsewhere on the board
TX9_P: J3.B42 (TX9+); also elsewhere on the board
TX10_N: J3.B46 (TX10-); also elsewhere on the board
TX10_P: J3.B45 (TX10+); also elsewhere on the board
TX11_N: J3.B49 (TX11-); also elsewhere on the board
TX11_P: J3.B48 (TX11+); also elsewhere on the board
TX12_N: J3.B52 (TX12-); also elsewhere on the board
TX12_P: J3.B51 (TX12+); also elsewhere on the board
TX13_N: J3.B55 (TX13-); also elsewhere on the board
TX13_P: J3.B54 (TX13+); also elsewhere on the board
TX14_N: J3.B58 (TX14-); also elsewhere on the board
TX14_P: J3.B57 (TX14+); also elsewhere on the board
TX15_N: J3.B61 (TX15-); also elsewhere on the board
TX15_P: J3.B60 (TX15+); also elsewhere on the board
WAKE: J3.A27 (FLEX4), TP3.1; also elsewhere on the board

Parts:
J2: 10146065-113Y1LF; AMPHENOL_10146065-113Y1LF-x16; PARTREV E

Connections:
3V3_AUX: J2.B10 (3.3Vaux); also elsewhere on the board
+3V3: J2.A9 (+3.3V), J2.A10 (+3.3V), J2.B8 (+3.3V); also elsewhere on the board
+12V: J2.A2 (+12V), J2.A3 (+12V), J2.B1 (+12V), J2.B2 (+12V), J2.B3 (+12V); also elsewhere on the board
CLK_N: J2.A14 (REFCLK-); also elsewhere on the board
CLK_P: J2.A13 (REFCLK+); also elsewhere on the board
GND: J2.A4 (GND), J2.A12 (GND), J2.A15 (GND), J2.A18 (GND), J2.A20 (GND), J2.A23 (GND), J2.A24 (GND), J2.A27 (GND), J2.A28 (GND), J2.A31 (GND), J2.A34 (GND), J2.A37 (GND), J2.A38 (GND), J2.A41 (GND), J2.A42 (GND), J2.A45 (GND), J2.A46 (GND), J2.A49 (GND), J2.A51 (GND), J2.A54 (GND), J2.A55 (GND), J2.A58 (GND), J2.A59 (GND), J2.A62 (GND), J2.A63 (GND), J2.A66 (GND), J2.A67 (GND), J2.A70 (GND), J2.A71 (GND), J2.A74 (GND), J2.A75 (GND), J2.A78 (GND), J2.A79 (GND), J2.A82 (GND), J2.B4 (GND), J2.B7 (GND), J2.B13 (GND), J2.B16 (GND), J2.B18 (GND), J2.B21 (GND), J2.B22 (GND), J2.B25 (GND), J2.B26 (GND), J2.B29 (GND), J2.B32 (GND), J2.B35 (GND), J2.B36 (GND), J2.B39 (GND), J2.B40 (GND), J2.B43 (GND), J2.B44 (GND), J2.B47 (GND), J2.B49 (GND), J2.B52 (GND), J2.B53 (GND), J2.B56 (GND), J2.B57 (GND), J2.B60 (GND), J2.B61 (GND), J2.B64 (GND), J2.B65 (GND), J2.B68 (GND), J2.B69 (GND), J2.B72 (GND), J2.B73 (GND), J2.B76 (GND), J2.B77 (GND), J2.B80 (GND); also elsewhere on the board
PERST: J2.A11 (~PERST); also elsewhere on the board
PRES: J2.B81 (~PRSNT2); also elsewhere on the board
RX0_N: J2.A17 (PERn0); also elsewhere on the board
RX0_P: J2.A16 (PERp0); also elsewhere on the board
RX1_N: J2.A22 (PERn1); also elsewhere on the board
RX1_P: J2.A21 (PERp1); also elsewhere on the board
RX2_N: J2.A26 (PERn2); also elsewhere on the board
RX2_P: J2.A25 (PERp2); also elsewhere on the board
RX3_N: J2.A30 (PERn3); also elsewhere on the board
RX3_P: J2.A29 (PERp3); also elsewhere on the board
RX4_N: J2.A36 (PERn4); also elsewhere on the board
RX4_P: J2.A35 (PERp4); also elsewhere on the board
RX5_N: J2.A40 (PERn5); also elsewhere on the board
RX5_P: J2.A39 (PERp5); also elsewhere on the board
RX6_N: J2.A44 (PERn6); also elsewhere on the board
RX6_P: J2.A43 (PERp6); also elsewhere on the board
RX7_N: J2.A48 (PERn7); also elsewhere on the board
RX7_P: J2.A47 (PERp7); also elsewhere on the board
RX8_N: J2.A53 (PERn8); also elsewhere on the board
RX8_P: J2.A52 (PERp8); also elsewhere on the board
RX9_N: J2.A57 (PERn9); also elsewhere on the board
RX9_P: J2.A56 (PERp9); also elsewhere on the board
RX10_N: J2.A61 (PERn10); also elsewhere on the board
RX10_P: J2.A60 (PERp10); also elsewhere on the board
RX11_N: J2.A65 (PERn11); also elsewhere on the board
RX11_P: J2.A64 (PERp11); also elsewhere on the board
RX12_N: J2.A69 (PERn12); also elsewhere on the board
RX12_P: J2.A68 (PERp12); also elsewhere on the board
RX13_N: J2.A73 (PERn13); also elsewhere on the board
RX13_P: J2.A72 (PERp13); also elsewhere on the board
RX14_N: J2.A77 (PERn14); also elsewhere on the board
RX14_P: J2.A76 (PERp14); also elsewhere on the board
RX15_N: J2.A81 (PERn15); also elsewhere on the board
RX15_P: J2.A80 (PERp15); also elsewhere on the board
SCL: J2.B5 (SMCLK); also elsewhere on the board
SDA: J2.B6 (SMDAT); also elsewhere on the board
TX0_N: J2.B15 (PETn0); also elsewhere on the board
TX0_P: J2.B14 (PETp0); also elsewhere on the board
TX1_N: J2.B20 (PETn1); also elsewhere on the board
TX1_P: J2.B19 (PETp1); also elsewhere on the board
TX2_N: J2.B24 (PETn2); also elsewhere on the board
TX2_P: J2.B23 (PETp2); also elsewhere on the board
TX3_N: J2.B28 (PETn3); also elsewhere on the board
TX3_P: J2.B27 (PETp3); also elsewhere on the board
TX4_N: J2.B34 (PETn4); also elsewhere on the board
TX4_P: J2.B33 (PETp4); also elsewhere on the board
TX5_N: J2.B38 (PETn5); also elsewhere on the board
TX5_P: J2.B37 (PETp5); also elsewhere on the board
TX6_N: J2.B42 (PETn6); also elsewhere on the board
TX6_P: J2.B41 (PETp6); also elsewhere on the board
TX7_N: J2.B46 (PETn7); also elsewhere on the board
TX7_P: J2.B45 (PETp7); also elsewhere on the board
TX8_N: J2.B51 (PETn8); also elsewhere on the board
TX8_P: J2.B50 (PETp8); also elsewhere on the board
TX9_N: J2.B55 (PETn9); also elsewhere on the board
TX9_P: J2.B54 (PETp9); also elsewhere on the board
TX10_N: J2.B59 (PETn10); also elsewhere on the board
TX10_P: J2.B58 (PETp10); also elsewhere on the board
TX11_N: J2.B63 (PETn11); also elsewhere on the board
TX11_P: J2.B62 (PETp11); also elsewhere on the board
TX12_N: J2.B67 (PETn12); also elsewhere on the board
TX12_P: J2.B66 (PETp12); also elsewhere on the board
TX13_N: J2.B71 (PETn13); also elsewhere on the board
TX13_P: J2.B70 (PETp13); also elsewhere on the board
TX14_N: J2.B75 (PETn14); also elsewhere on the board
TX14_P: J2.B74 (PETp14); also elsewhere on the board
TX15_N: J2.B79 (PETn15); also elsewhere on the board
TX15_P: J2.B78 (PETp15); also elsewhere on the board
WAKE: J2.B11 (~WAKE); also elsewhere on the board

Board: 6 copper layers, 110.0 x 45.0 mm, 35 parts (0 on the bottom side), 81 nets.

Other parts of the board:
H1, H4: MountingHole_3.2mm_M3_Pad_Via

Their connections:
GND: H1.1, H4.1; also elsewhere on the board

## Commit log (part)

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2026-04-06 updated stackup and regulator
2026-06-28 update xschematic
